<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PWR_test_receiver</value></param>
<param><key>author</key><value>Peter F Bradshaw</value></param>
<param><key>description</key><value>This is a test receiver for the of the Passive Weather Radar</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Passive Weather Radar test receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8388608</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>correlation_vector_to_stream</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reference_fft</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(1024)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>refernce_stream_to_vector</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_reference_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>882.5e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_target_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>882.5e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>target_fft</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(1024)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>target_stream_to_vector</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>correlation_vector_to_stream</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correlation_vector_to_stream</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reference_fft</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>refernce_stream_to_vector</source_block_id><sink_block_id>reference_fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_reference_source</source_block_id><sink_block_id>refernce_stream_to_vector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_target_source</source_block_id><sink_block_id>target_stream_to_vector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>target_fft</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>target_stream_to_vector</source_block_id><sink_block_id>target_fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
