options:
  parameters:
    author: pfb
    generate_options: qt_gui
    id: SSS_Sync
    output_language: python
    title: SSS Sync
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: blocks_file_descriptor_sink_0
  id: blocks_file_descriptor_sink
  parameters:
    fd: '1'
    type: complex
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: lte_extract_subcarriers_vcvc_0
  id: lte_extract_subcarriers_vcvc
  parameters:
    N_rb_dl: '6'
    fftl: '2048'
  states: {}
- name: lte_sss_calculator_vcm_0
  id: lte_sss_calculator_vcm
  parameters:
    fftl: '2048'
    in_key: ''
    out_key: ''
  states: {}
- name: lte_sss_symbol_selector_cvc_0
  id: lte_sss_symbol_selector_cvc
  parameters:
    fftl: '2048'
  states: {}
- name: lte_sss_tagger_cc_0
  id: lte_sss_tagger_cc
  parameters:
    fftl: ''
  states: {}

connections:
- [blocks_file_descriptor_source_0, '0', lte_sss_symbol_selector_cvc_0, '0']
- [blocks_file_descriptor_source_0, '0', lte_sss_tagger_cc_0, '0']
- [fft_vxx_0, '0', lte_extract_subcarriers_vcvc_0, '0']
- [lte_extract_subcarriers_vcvc_0, '0', lte_sss_calculator_vcm_0, '0']
- [lte_sss_calculator_vcm_0, cell_id, blocks_message_debug_0, print_pdu]
- [lte_sss_calculator_vcm_0, frame_start, lte_sss_tagger_cc_0, frame_start]
- [lte_sss_symbol_selector_cvc_0, '0', fft_vxx_0, '0']
- [lte_sss_tagger_cc_0, '0', blocks_file_descriptor_sink_0, '0']

metadata:
  file_format: 1
