options:
  parameters:
    author: pfb
    description: Read a test data file and present it to the appropiate LTE block
    generate_options: qt_gui
    id: LTE_test
    output_language: python
    title: LTE test
  states: {}

blocks:
- name: fftlen
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (7*fftlen + 160* fftlen/2048 + 6 * (144 * fftlen/2048)) / 0.0005
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ~/Work/PWR/test/Development/GNURadio/LTE_test_file_int8.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: lte_top_block_siso_0
  id: lte_top_block_siso
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 0.5 * samp_rate
    fc: '0'
    fftsize: fftlen
    name: '"Input f Sink"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fftlen
    name: '"Input"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_pss
  id: qtgui_sink_x
  parameters:
    bw: 0.5 * samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"PSS Sync"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_sss
  id: qtgui_sink_x
  parameters:
    bw: 0.5 * samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"SSS Synch"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: remote_rtl_sdr_0
  id: remote_rtl_sdr
  parameters: {}
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', remote_rtl_sdr_0, '0']
- [lte_top_block_siso_0, '0', blocks_null_sink_1, '0']
- [lte_top_block_siso_0, '0', qtgui_sink_x_sss, '0']
- [lte_top_block_siso_0, '1', blocks_null_sink_0, '0']
- [lte_top_block_siso_0, '1', qtgui_sink_x_pss, '0']
- [remote_rtl_sdr_0, '0', lte_top_block_siso_0, '0']
- [remote_rtl_sdr_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', lte_top_block_siso_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
