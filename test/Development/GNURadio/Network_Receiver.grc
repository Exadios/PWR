<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>882500000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>700000000</value></param>
<param><key>step</key><value>2048</value></param>
<param><key>stop</key><value>950000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2097152</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vector_length</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>RTL_SDR_Receiver</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>vlen</key><value>8192</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>8192</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>24000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>correlation_vector_to_stream</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>8192</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft</value></param>
<param><key>fft_size</key><value>vector_length</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(vector_length)</value></param>
</block>
<connection><source_block_id>RTL_SDR_Receiver</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>correlation_vector_to_stream</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correlation_vector_to_stream</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
