options:
  parameters:
    author: pfb
    description: Connect and convert a remote rtl_sdr
    generate_options: hb
    id: remote_rtl_sdr
    output_language: python
    title: rtl_sdr on Pi
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    optional: 'True'
    type: byte
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_uchar_to_float_1, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_float_to_complex_0, '1']
- [blocks_uchar_to_float_1, '0', blocks_null_sink_1, '0']
- [pad_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
