options:
  parameters:
    author: Peter F Bradshaw
    description: This is a test receiver for the of the Passive Weather Radar
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: PWR_test_receiver
    output_language: python
    title: Passive Weather Radar test receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8388608'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: '1024'
  states: {}
- name: correlation_vector_to_stream
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqchangevar: None
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: reference_fft
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(1024)
  states: {}
- name: refernce_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: rtlsdr_reference_source
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 882.5e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: ''
    type: fc32
  states: {}
- name: rtlsdr_target_source
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 882.5e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: ''
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: target_fft
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(1024)
  states: {}
- name: target_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', correlation_vector_to_stream, '0']
- [correlation_vector_to_stream, '0', qtgui_sink_x_0, '0']
- [reference_fft, '0', blocks_multiply_conjugate_cc_0, '0']
- [refernce_stream_to_vector, '0', reference_fft, '0']
- [rtlsdr_reference_source, '0', refernce_stream_to_vector, '0']
- [rtlsdr_target_source, '0', target_stream_to_vector, '0']
- [target_fft, '0', blocks_multiply_conjugate_cc_0, '1']
- [target_stream_to_vector, '0', target_fft, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-944-g884e8f6d
