options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2097152'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: RTL_SDR_Receiver
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pfb/Work/PWR/test/Development/GNURadio/test_data/690.0501120mHz.raw
    type: complex
    unbuffered: 'True'
  states: {}
- name: center_frequency
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: eng_float
    value: '778000000'
  states: {}

connections:
- [RTL_SDR_Receiver, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
