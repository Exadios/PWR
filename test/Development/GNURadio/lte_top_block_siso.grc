options:
  parameters:
    author: Johannes Demel
    category: Custom
    generate_options: hb
    generator_class_name: PythonHierBlockNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_hb_nogui
    id: lte_top_block_siso
    output_language: python
    title: LTE top level flowgraph SISO
  states: {}

blocks:
- name: N_rb_dl
  id: variable
  parameters:
    value: '6'
  states: {}
- name: fftlen
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frame_key
  id: variable
  parameters:
    value: '"slot"'
  states: {}
- name: interp_val
  id: variable
  parameters:
    value: int(samp_rate/1e4)
  states: {state: disabled}
- name: pbch_descr_key
  id: variable
  parameters:
    value: '"descr_part"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (7*fftlen + 160* fftlen/2048 + 6 * (144 * fftlen/2048)) / 0.0005
  states: {}
- name: MIB
  id: lte_mib_unpack_vbm
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/1e4
    type: complex
  states: {}
- name: lte_bch_decoder_0
  id: lte_bch_decoder
  parameters: {}
  states: {state: disabled}
- name: lte_channel_estimator_0
  id: lte_channel_estimator
  parameters:
    N_rb_dl: N_rb_dl
    estimator_key: '"slot"'
    initial_id: '124'
  states: {state: disabled}
- name: lte_cp_ffo_sync_0
  id: lte_cp_ffo_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_ofdm_demodulator_0
  id: lte_ofdm_demodulator
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    ofdm_key: '"slot"'
  states: {state: disabled}
- name: lte_pbch_decoder_0
  id: lte_pbch_decoder
  parameters:
    N_rb_dl: '50'
  states: {state: disabled}
- name: lte_pcfich_decoder_0
  id: lte_pcfich_decoder
  parameters:
    N_rb_dl: N_rb_dl
    key: '"slot"'
  states: {state: disabled}
- name: lte_pss_sync_0
  id: lte_pss_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_sss_sync_0
  id: lte_sss_sync
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    group_key: '"N_id_2"'
    offset_key: '"offset_marker"'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: SSS_sync
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: Channel_Estimator_1
    type: complex
    vlen: '600'
  states: {state: disabled}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: Channel_Estimator_0
    type: complex
    vlen: '600'
  states: {state: disabled}
- name: pad_sink_1_1
  id: pad_sink
  parameters:
    label: OFDM Demod
    type: complex
    vlen: '600'
  states: {state: disabled}
- name: pad_sink_1_2
  id: pad_sink
  parameters:
    label: PSS_sync
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: sync_lte_rough_symbol_sync_cc_0
  id: lte_rough_symbol_sync_cc
  parameters:
    fftl: fftlen
    vlen: '1'
  states: {}

connections:
- [MIB, N_ant, lte_pcfich_decoder_0, N_ant]
- [blocks_throttle_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [lte_bch_decoder_0, '0', MIB, '0']
- [lte_bch_decoder_0, '1', MIB, '1']
- [lte_channel_estimator_0, '0', lte_pbch_decoder_0, '1']
- [lte_channel_estimator_0, '0', lte_pcfich_decoder_0, '1']
- [lte_channel_estimator_0, '0', pad_sink_1_0_0, '0']
- [lte_channel_estimator_0, '1', lte_pbch_decoder_0, '2']
- [lte_channel_estimator_0, '1', lte_pcfich_decoder_0, '2']
- [lte_channel_estimator_0, '1', pad_sink_1_0, '0']
- [lte_cp_ffo_sync_0, '0', lte_sss_sync_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_channel_estimator_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pbch_decoder_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pcfich_decoder_0, '0']
- [lte_ofdm_demodulator_0, '0', pad_sink_1_1, '0']
- [lte_pbch_decoder_0, '0', lte_bch_decoder_0, '0']
- [lte_pss_sync_0, '0', lte_cp_ffo_sync_0, '0']
- [lte_pss_sync_0, '0', pad_sink_1_2, '0']
- [lte_sss_sync_0, '0', lte_ofdm_demodulator_0, '0']
- [lte_sss_sync_0, '0', pad_sink_1, '0']
- [lte_sss_sync_0, cell_id, blocks_message_debug_0, print]
- [lte_sss_sync_0, cell_id, lte_channel_estimator_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pbch_decoder_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pcfich_decoder_0, cell_id]
- [pad_source_0, '0', blocks_throttle_0, '0']
- [sync_lte_rough_symbol_sync_cc_0, '0', lte_pss_sync_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-944-g884e8f6d
